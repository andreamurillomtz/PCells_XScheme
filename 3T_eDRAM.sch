** sch_path: 3T_eDRAM.sch
**.subckt 3T_eDRAM
X1 RBL net3 net1 irf5305
X2 RBL RBL net2 irf5305
X3 GND net1 net2 irf5305
**.ends
.GLOBAL GND
.end
