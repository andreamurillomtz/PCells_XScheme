** sch_path: 1T1C_eDRAM.sch
**.subckt 1T1C_eDRAM
M1 BL WL net1 M2N7002 m=1
C1 net1 xxx 1p m=1
**.ends
.end
